Commit message: Pybullet ray intersection implemented for all objects

File: urdf/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=2 2 0.1; visual mesh filename=plane.obj scale=1 1 1
